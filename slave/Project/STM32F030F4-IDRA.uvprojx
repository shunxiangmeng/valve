# Keil uVision project STM32F030F4-IDRA.uvprojx, settings and files
target STM32F0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: kfq-v2 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\ST_Lib\inc;..\ST_Lib\src;..\System\CMSIS;..\System\startup;..\User;..\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group System
    ../System/startup/: startup_stm32f0xx_ld.s
    ../System/CMSIS/: core_cm0.h core_cm0plus.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
    ./: Include.h
  group ST_Lib
    ../ST_Lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_flash.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_misc.c
  group App
    ../App/: main.c
  group Bsp
    ../Bsp/: delay.c led.c pwm.c usart.c flash_ee.c
